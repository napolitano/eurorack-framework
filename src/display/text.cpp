/**
 * @file src/display/text.cpp
 * @brief Implements bitmap-font text rendering and alignment.
 *
 * @details
 * Measures and renders single-line bitmap text on a monochrome canvas.
 * Layout separates glyph advance from drawn width so trailing spacing is not mistaken for visible
 * content. Horizontal and vertical alignment are calculated from the measured bounds before any
 * pixel is emitted. Unsupported characters use the font fallback glyph, and clipping remains the
 * canvas responsibility.
 *
 * @author Axel Napolitano
 * @date 2026
 * @par Contact
 * eurorack\@skjt.de
 *
 * @par License
 * PolyForm Noncommercial License 1.0.0
 * SPDX-License-Identifier: PolyForm-Noncommercial-1.0.0
 */

#include <algorithm>
#include <array>
#include <eurorack/display/drawing.hpp>
#include <eurorack/display/text.hpp>

namespace eurorack::display {

namespace {

constexpr std::array<std::uint8_t, 475> FONT_5X7_DATA{
    0x00U, 0x00U, 0x00U, 0x00U, 0x00U, 0x00U, 0x00U, 0x5FU, 0x00U, 0x00U, 0x00U, 0x07U, 0x00U,
    0x07U, 0x00U, 0x14U, 0x7FU, 0x14U, 0x7FU, 0x14U, 0x24U, 0x2AU, 0x7FU, 0x2AU, 0x12U, 0x23U,
    0x13U, 0x08U, 0x64U, 0x62U, 0x36U, 0x49U, 0x55U, 0x22U, 0x50U, 0x00U, 0x05U, 0x03U, 0x00U,
    0x00U, 0x00U, 0x1CU, 0x22U, 0x41U, 0x00U, 0x00U, 0x41U, 0x22U, 0x1CU, 0x00U, 0x14U, 0x08U,
    0x3EU, 0x08U, 0x14U, 0x08U, 0x08U, 0x3EU, 0x08U, 0x08U, 0x00U, 0x50U, 0x30U, 0x00U, 0x00U,
    0x08U, 0x08U, 0x08U, 0x08U, 0x08U, 0x00U, 0x60U, 0x60U, 0x00U, 0x00U, 0x20U, 0x10U, 0x08U,
    0x04U, 0x02U, 0x3EU, 0x51U, 0x49U, 0x45U, 0x3EU, 0x00U, 0x42U, 0x7FU, 0x40U, 0x00U, 0x42U,
    0x61U, 0x51U, 0x49U, 0x46U, 0x21U, 0x41U, 0x45U, 0x4BU, 0x31U, 0x18U, 0x14U, 0x12U, 0x7FU,
    0x10U, 0x27U, 0x45U, 0x45U, 0x45U, 0x39U, 0x3CU, 0x4AU, 0x49U, 0x49U, 0x30U, 0x01U, 0x71U,
    0x09U, 0x05U, 0x03U, 0x36U, 0x49U, 0x49U, 0x49U, 0x36U, 0x06U, 0x49U, 0x49U, 0x29U, 0x1EU,
    0x00U, 0x36U, 0x36U, 0x00U, 0x00U, 0x00U, 0x56U, 0x36U, 0x00U, 0x00U, 0x08U, 0x14U, 0x22U,
    0x41U, 0x00U, 0x14U, 0x14U, 0x14U, 0x14U, 0x14U, 0x00U, 0x41U, 0x22U, 0x14U, 0x08U, 0x02U,
    0x01U, 0x51U, 0x09U, 0x06U, 0x32U, 0x49U, 0x79U, 0x41U, 0x3EU, 0x7EU, 0x11U, 0x11U, 0x11U,
    0x7EU, 0x7FU, 0x49U, 0x49U, 0x49U, 0x36U, 0x3EU, 0x41U, 0x41U, 0x41U, 0x22U, 0x7FU, 0x41U,
    0x41U, 0x22U, 0x1CU, 0x7FU, 0x49U, 0x49U, 0x49U, 0x41U, 0x7FU, 0x09U, 0x09U, 0x09U, 0x01U,
    0x3EU, 0x41U, 0x49U, 0x49U, 0x7AU, 0x7FU, 0x08U, 0x08U, 0x08U, 0x7FU, 0x00U, 0x41U, 0x7FU,
    0x41U, 0x00U, 0x20U, 0x40U, 0x41U, 0x3FU, 0x01U, 0x7FU, 0x08U, 0x14U, 0x22U, 0x41U, 0x7FU,
    0x40U, 0x40U, 0x40U, 0x40U, 0x7FU, 0x02U, 0x0CU, 0x02U, 0x7FU, 0x7FU, 0x04U, 0x08U, 0x10U,
    0x7FU, 0x3EU, 0x41U, 0x41U, 0x41U, 0x3EU, 0x7FU, 0x09U, 0x09U, 0x09U, 0x06U, 0x3EU, 0x41U,
    0x51U, 0x21U, 0x5EU, 0x7FU, 0x09U, 0x19U, 0x29U, 0x46U, 0x46U, 0x49U, 0x49U, 0x49U, 0x31U,
    0x01U, 0x01U, 0x7FU, 0x01U, 0x01U, 0x3FU, 0x40U, 0x40U, 0x40U, 0x3FU, 0x1FU, 0x20U, 0x40U,
    0x20U, 0x1FU, 0x3FU, 0x40U, 0x38U, 0x40U, 0x3FU, 0x63U, 0x14U, 0x08U, 0x14U, 0x63U, 0x07U,
    0x08U, 0x70U, 0x08U, 0x07U, 0x61U, 0x51U, 0x49U, 0x45U, 0x43U, 0x00U, 0x7FU, 0x41U, 0x41U,
    0x00U, 0x02U, 0x04U, 0x08U, 0x10U, 0x20U, 0x00U, 0x41U, 0x41U, 0x7FU, 0x00U, 0x04U, 0x02U,
    0x01U, 0x02U, 0x04U, 0x40U, 0x40U, 0x40U, 0x40U, 0x40U, 0x00U, 0x01U, 0x02U, 0x04U, 0x00U,
    0x20U, 0x54U, 0x54U, 0x54U, 0x78U, 0x7FU, 0x48U, 0x44U, 0x44U, 0x38U, 0x38U, 0x44U, 0x44U,
    0x44U, 0x20U, 0x38U, 0x44U, 0x44U, 0x48U, 0x7FU, 0x38U, 0x54U, 0x54U, 0x54U, 0x18U, 0x08U,
    0x7EU, 0x09U, 0x01U, 0x02U, 0x0CU, 0x52U, 0x52U, 0x52U, 0x3EU, 0x7FU, 0x08U, 0x04U, 0x04U,
    0x78U, 0x00U, 0x44U, 0x7DU, 0x40U, 0x00U, 0x20U, 0x40U, 0x44U, 0x3DU, 0x00U, 0x7FU, 0x10U,
    0x28U, 0x44U, 0x00U, 0x00U, 0x41U, 0x7FU, 0x40U, 0x00U, 0x7CU, 0x04U, 0x18U, 0x04U, 0x78U,
    0x7CU, 0x08U, 0x04U, 0x04U, 0x78U, 0x38U, 0x44U, 0x44U, 0x44U, 0x38U, 0x7CU, 0x14U, 0x14U,
    0x14U, 0x08U, 0x08U, 0x14U, 0x14U, 0x18U, 0x7CU, 0x7CU, 0x08U, 0x04U, 0x04U, 0x08U, 0x48U,
    0x54U, 0x54U, 0x54U, 0x20U, 0x04U, 0x3FU, 0x44U, 0x40U, 0x20U, 0x3CU, 0x40U, 0x40U, 0x20U,
    0x7CU, 0x1CU, 0x20U, 0x40U, 0x20U, 0x1CU, 0x3CU, 0x40U, 0x30U, 0x40U, 0x3CU, 0x44U, 0x28U,
    0x10U, 0x28U, 0x44U, 0x0CU, 0x50U, 0x50U, 0x50U, 0x3CU, 0x44U, 0x64U, 0x54U, 0x4CU, 0x44U,
    0x00U, 0x08U, 0x36U, 0x41U, 0x00U, 0x00U, 0x00U, 0x7FU, 0x00U, 0x00U, 0x00U, 0x41U, 0x36U,
    0x08U, 0x00U, 0x10U, 0x08U, 0x08U, 0x10U, 0x08U};

constexpr BitmapFont FONT_5X7{FONT_5X7_DATA.data(), 32U, 126U, 5U, 7U, 1U};

/*
 * Purpose: Calculates the upper-left origin for aligned text.
 * bounds: Rectangle in which text is aligned.
 * metrics: Measured pixel dimensions of the text.
 * style: Horizontal and vertical alignment policy.
 * Returns: Pixel origin that places the measured text according to `style`.
 */
Point alignedOrigin(const Rect bounds, const TextMetrics metrics, const TextStyle& style) noexcept {
    std::int32_t x = bounds.x;
    std::int32_t y = bounds.y;

    if (style.horizontalAlignment == HorizontalAlignment::Center) {
        x = bounds.x + (bounds.width - metrics.width) / 2;
    } else if (style.horizontalAlignment == HorizontalAlignment::Right) {
        x = bounds.x + bounds.width - metrics.width;
    }

    if (style.verticalAlignment == VerticalAlignment::Middle) {
        y = bounds.y + (bounds.height - metrics.height) / 2;
    } else if (style.verticalAlignment == VerticalAlignment::Bottom) {
        y = bounds.y + bounds.height - metrics.height;
    }

    return {x, y};
}

} // namespace

const BitmapFont& font5x7() noexcept {
    return FONT_5X7;
}

TextMetrics measureText(const std::string_view text, const BitmapFont& font) noexcept {
    if (text.empty()) {
        return {0, font.glyphHeight};
    }

    const std::size_t characterWidth = static_cast<std::size_t>(font.glyphWidth) +
                                       static_cast<std::size_t>(font.horizontalSpacing);

    const std::size_t width =
        text.size() * characterWidth - static_cast<std::size_t>(font.horizontalSpacing);

    return {static_cast<std::int32_t>(std::min<std::size_t>(width, 2147483647U)),
            static_cast<std::int32_t>(font.glyphHeight)};
}

void drawCharacter(MonochromeCanvas& canvas,
                   const Point origin,
                   const char character,
                   const BitmapFont& font,
                   const PixelOperation operation) noexcept {
    if (font.glyphData == nullptr || font.glyphWidth == 0U || font.glyphHeight == 0U) {
        return;
    }

    const auto code = static_cast<std::uint8_t>(character);
    const std::uint8_t safeCode = code >= font.firstCharacter && code <= font.lastCharacter
                                      ? code
                                      : static_cast<std::uint8_t>('?');

    const std::size_t glyphIndex = static_cast<std::size_t>(safeCode - font.firstCharacter);
    const std::size_t offset = glyphIndex * static_cast<std::size_t>(font.glyphWidth);

    for (std::uint8_t column = 0U; column < font.glyphWidth; ++column) {
        const std::uint8_t bits = font.glyphData[offset + column];

        for (std::uint8_t row = 0U; row < font.glyphHeight; ++row) {
            if ((bits & static_cast<std::uint8_t>(1U << row)) != 0U) {
                canvas.applyPixel({origin.x + static_cast<std::int32_t>(column),
                                   origin.y + static_cast<std::int32_t>(row)},
                                  operation);
            }
        }
    }
}

void drawText(MonochromeCanvas& canvas,
              Point origin,
              const std::string_view text,
              const BitmapFont& font,
              const PixelOperation operation) noexcept {
    const std::int32_t advance =
        static_cast<std::int32_t>(font.glyphWidth + font.horizontalSpacing);

    for (const char character : text) {
        drawCharacter(canvas, origin, character, font, operation);
        origin.x += advance;
    }
}

void drawText(MonochromeCanvas& canvas,
              const Rect bounds,
              const std::string_view text,
              const TextStyle& style,
              const BitmapFont& font) noexcept {
    const TextMetrics metrics = measureText(text, font);
    const Point origin = alignedOrigin(bounds, metrics, style);
    const Rect previousClip = canvas.clipRect();

    if (style.clipToBounds) {
        canvas.setClipRect(bounds);
    }

    if (style.mode == TextMode::Inverted) {
        fillRectangle(canvas, bounds, style.foreground);
        drawText(canvas, origin, text, font, style.background);
    } else {
        drawText(canvas, origin, text, font, style.foreground);
    }

    if (style.clipToBounds) {
        canvas.setClipRect(previousClip);
    }
}

} // namespace eurorack::display
